# IAR project GUI.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SWM341xE Synwit SWM341xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 71
  General.FPU2: 6
  ICCARM.CCDiagSuppress: Pa089
  ICCARM.CCIncludePath2: Source\DeviceSupport; Source\CoreSupport; Source\Application\Include; Source\Board\Include; Source\ThirdParty\lvgl\src; Source\ThirdParty\lvgl\src\display; Source\ThirdParty\lvgl\src\core; Source\ThirdParty\lvgl\src\draw; Source\ThirdParty\lvgl\src\draw\sw; Source\ThirdParty\lvgl\src\draw\sw\blend; Source\ThirdParty\lvgl\src\font; Source\ThirdParty\lvgl\src\indev; Source\ThirdParty\lvgl\src\layouts; Source\ThirdParty\lvgl\src\layouts\flex; Source\ThirdParty\lvgl\src\layouts\grid; Source\ThirdParty\lvgl\src\libs; Source\ThirdParty\lvgl\src\libs\barcode; Source\ThirdParty\lvgl\src\libs\bmp; Source\ThirdParty\lvgl\src\libs\ffmpeg; Source\ThirdParty\lvgl\src\libs\freetype; Source\ThirdParty\lvgl\src\libs\fsdrv; Source\ThirdParty\lvgl\src\libs\gif; Source\ThirdParty\lvgl\src\libs\libjpeg_turbo; Source\ThirdParty\lvgl\src\libs\libpng; Source\ThirdParty\lvgl\src\libs\lodepng; Source\ThirdParty\lvgl\src\libs\qrcode; Source\ThirdParty\lvgl\src\libs\rlottie; Source\ThirdParty\lvgl\src\libs\tiny_ttf; Source\ThirdParty\lvgl\src\libs\tjpgd; Source\ThirdParty\lvgl\src\misc; Source\ThirdParty\lvgl\src\osal; Source\ThirdParty\lvgl\src\others; Source\ThirdParty\lvgl\src\others\file_explorer; Source\ThirdParty\lvgl\src\others\fragment; Source\ThirdParty\lvgl\src\others\gridnav; Source\ThirdParty\lvgl\src\others\ime; Source\ThirdParty\lvgl\src\others\imgfont; Source\ThirdParty\lvgl\src\others\monkey; Source\ThirdParty\lvgl\src\others\observer; Source\ThirdParty\lvgl\src\others\snapshot; Source\ThirdParty\lvgl\src\others\sysmon; Source\ThirdParty\lvgl\src\themes; Source\ThirdParty\lvgl\src\themes\basic; Source\ThirdParty\lvgl\src\themes\default; Source\ThirdParty\lvgl\src\themes\mono; Source\ThirdParty\lvgl\src\tick; Source\ThirdParty\lvgl\src\widgets; Source\ThirdParty\lvgl\src\widgets\animimage; Source\ThirdParty\lvgl\src\widgets\arc; Source\ThirdParty\lvgl\src\widgets\bar; Source\ThirdParty\lvgl\src\widgets\button; Source\ThirdParty\lvgl\src\widgets\buttonmatrix; Source\ThirdParty\lvgl\src\widgets\calendar; Source\ThirdParty\lvgl\src\widgets\canvas; Source\ThirdParty\lvgl\src\widgets\chart; Source\ThirdParty\lvgl\src\widgets\checkbox; Source\ThirdParty\lvgl\src\widgets\dropdown; Source\ThirdParty\lvgl\src\widgets\image; Source\ThirdParty\lvgl\src\widgets\imgbtn; Source\ThirdParty\lvgl\src\widgets\keyboard; Source\ThirdParty\lvgl\src\widgets\label; Source\ThirdParty\lvgl\src\widgets\led; Source\ThirdParty\lvgl\src\widgets\line; Source\ThirdParty\lvgl\src\widgets\list; Source\ThirdParty\lvgl\src\widgets\menu; Source\ThirdParty\lvgl\src\widgets\msgbox; Source\ThirdParty\lvgl\src\widgets\objx_templ; Source\ThirdParty\lvgl\src\widgets\roller; Source\ThirdParty\lvgl\src\widgets\scale; Source\ThirdParty\lvgl\src\widgets\slider; Source\ThirdParty\lvgl\src\widgets\span; Source\ThirdParty\lvgl\src\widgets\spinbox; Source\ThirdParty\lvgl\src\widgets\spinner; Source\ThirdParty\lvgl\src\widgets\switch; Source\ThirdParty\lvgl\src\widgets\table; Source\ThirdParty\lvgl\src\widgets\tabview; Source\ThirdParty\lvgl\src\widgets\textarea; Source\ThirdParty\lvgl\src\widgets\tileview; Source\ThirdParty\lvgl\src\widgets\win; Source\ThirdParty\lvgl\src\stdlib; Source\ThirdParty\lvgl\src\stdlib\builtin; Source\ThirdParty\lvgl\demos; Source\ThirdParty\FreeRTOS-Kernel\include; Source\ThirdParty\FreeRTOS-Kernel\portable\IAR\ARM_CM33_NTZ\non_secure
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: Source\ThirdParty\FreeRTOS-Kernel\include; Source\ThirdParty\FreeRTOS-Kernel\portable\IAR\ARM_CM33_NTZ\non_secure; Source\Application\Include
  OBJCOPY.OOCOutputFile: GUI.srec
  ILINK.IlinkOutputFile: GUI.out
  ILINK.IlinkIcfFile: SWM341SRET6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    Source/Application/: LowLevelIOInterface.c main.c SystemInit.c
    Source/DeviceSupport/: startup_SWM341.s
  group BSP
    Source/Board/: FT5206.c OTM8009A.c
  group ThirdParty/FreeRTOS
    Source/ThirdParty/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group ThirdParty/FreeRTOS/port
    Source/ThirdParty/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    Source/ThirdParty/FreeRTOS-Kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group ThirdParty/LVGL
    Source/ThirdParty/lvgl/src/: lv_init.c
    Source/Application/: lv_port_disp.c lv_port_indev.c
  group ThirdParty/LVGL/core
    Source/ThirdParty/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group ThirdParty/LVGL/demos
    Source/ThirdParty/lvgl/demos/: lv_demos.c
  group ThirdParty/LVGL/demos/widgets
    Source/ThirdParty/lvgl/demos/widgets/: lv_demo_widgets.c
  group ThirdParty/LVGL/demos/widgets/assets
    Source/ThirdParty/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
  group ThirdParty/LVGL/display
    Source/ThirdParty/lvgl/src/display/: lv_display.c
  group ThirdParty/LVGL/draw
    Source/ThirdParty/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_image_buf.c lv_image_decoder.c
  group ThirdParty/LVGL/draw/sw
    Source/ThirdParty/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_bg_img.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask.h lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c
  group ThirdParty/LVGL/draw/sw/blend
    Source/ThirdParty/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
  group ThirdParty/LVGL/font
    Source/ThirdParty/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group ThirdParty/LVGL/indev
    Source/ThirdParty/lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
  group ThirdParty/LVGL/layouts
    Source/ThirdParty/lvgl/src/layouts/: lv_layout.c
  group ThirdParty/LVGL/layouts/flex
    Source/ThirdParty/lvgl/src/layouts/flex/: lv_flex.c
  group ThirdParty/LVGL/layouts/grid
    Source/ThirdParty/lvgl/src/layouts/grid/: lv_grid.c
  group ThirdParty/LVGL/libs/barcode
    Source/ThirdParty/lvgl/src/libs/barcode/: code128.c lv_barcode.c
  group ThirdParty/LVGL/libs/bmp
    Source/ThirdParty/lvgl/src/libs/bmp/: lv_bmp.c
  group ThirdParty/LVGL/libs/ffmpeg
    Source/ThirdParty/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
  group ThirdParty/LVGL/libs/freetype
    Source/ThirdParty/lvgl/src/libs/freetype/: lv_freetype.c lv_ftsystem.c
  group ThirdParty/LVGL/libs/fsdrv
    Source/ThirdParty/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
  group ThirdParty/LVGL/libs/gif
    Source/ThirdParty/lvgl/src/libs/gif/: gifdec.c lv_gif.c
  group ThirdParty/LVGL/libs/libjpeg_turbo
    Source/ThirdParty/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
  group ThirdParty/LVGL/libs/libpng
    Source/ThirdParty/lvgl/src/libs/libpng/: lv_libpng.c
  group ThirdParty/LVGL/libs/lodepng
    Source/ThirdParty/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
  group ThirdParty/LVGL/libs/qrcode
    Source/ThirdParty/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group ThirdParty/LVGL/libs/rlottie
    Source/ThirdParty/lvgl/src/libs/rlottie/: lv_rlottie.c
  group ThirdParty/LVGL/libs/tiny_ttf
    Source/ThirdParty/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
  group ThirdParty/LVGL/libs/tjpgd
    Source/ThirdParty/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
  group ThirdParty/LVGL/misc
    Source/ThirdParty/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_cache.c lv_cache_builtin.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_palette.c lv_profiler_builtin.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
  group ThirdParty/LVGL/osal
    Source/ThirdParty/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_os_none.c lv_pthread.c lv_rtthread.c
  group ThirdParty/LVGL/others/file_explorer
    Source/ThirdParty/lvgl/src/others/file_explorer/: lv_file_explorer.c
  group ThirdParty/LVGL/others/fragment
    Source/ThirdParty/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
  group ThirdParty/LVGL/others/gridnav
    Source/ThirdParty/lvgl/src/others/gridnav/: lv_gridnav.c
  group ThirdParty/LVGL/others/ime
    Source/ThirdParty/lvgl/src/others/ime/: lv_ime_pinyin.c
  group ThirdParty/LVGL/others/imgfont
    Source/ThirdParty/lvgl/src/others/imgfont/: lv_imgfont.c
  group ThirdParty/LVGL/others/monkey
    Source/ThirdParty/lvgl/src/others/monkey/: lv_monkey.c
  group ThirdParty/LVGL/others/observer
    Source/ThirdParty/lvgl/src/others/observer/: lv_observer.c
  group ThirdParty/LVGL/others/snapshot
    Source/ThirdParty/lvgl/src/others/snapshot/: lv_snapshot.c
  group ThirdParty/LVGL/others/sysmon
    Source/ThirdParty/lvgl/src/others/sysmon/: lv_sysmon.c
  group ThirdParty/LVGL/stdlib
    Source/ThirdParty/lvgl/src/stdlib/: lv_mem.c
    Source/ThirdParty/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group ThirdParty/LVGL/themes
    Source/ThirdParty/lvgl/src/themes/: lv_theme.c
  group ThirdParty/LVGL/themes/basic
    Source/ThirdParty/lvgl/src/themes/basic/: lv_theme_basic.c
  group ThirdParty/LVGL/themes/default
    Source/ThirdParty/lvgl/src/themes/default/: lv_theme_default.c
  group ThirdParty/LVGL/themes/mono
    Source/ThirdParty/lvgl/src/themes/mono/: lv_theme_mono.c
  group ThirdParty/LVGL/tick
    Source/ThirdParty/lvgl/src/tick/: lv_tick.c
  group ThirdParty/LVGL/widgets
    Source/ThirdParty/lvgl/src/widgets/animimage/: lv_animimage.c
    Source/ThirdParty/lvgl/src/widgets/arc/: lv_arc.c
    Source/ThirdParty/lvgl/src/widgets/bar/: lv_bar.c
    Source/ThirdParty/lvgl/src/widgets/button/: lv_button.c
    Source/ThirdParty/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    Source/ThirdParty/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    Source/ThirdParty/lvgl/src/widgets/canvas/: lv_canvas.c
    Source/ThirdParty/lvgl/src/widgets/chart/: lv_chart.c
    Source/ThirdParty/lvgl/src/widgets/checkbox/: lv_checkbox.c
    Source/ThirdParty/lvgl/src/widgets/dropdown/: lv_dropdown.c
    Source/ThirdParty/lvgl/src/widgets/image/: lv_image.c
    Source/ThirdParty/lvgl/src/widgets/imgbtn/: lv_imgbtn.c
    Source/ThirdParty/lvgl/src/widgets/keyboard/: lv_keyboard.c
    Source/ThirdParty/lvgl/src/widgets/label/: lv_label.c
    Source/ThirdParty/lvgl/src/widgets/led/: lv_led.c
    Source/ThirdParty/lvgl/src/widgets/line/: lv_line.c
    Source/ThirdParty/lvgl/src/widgets/list/: lv_list.c
    Source/ThirdParty/lvgl/src/widgets/menu/: lv_menu.c
    Source/ThirdParty/lvgl/src/widgets/msgbox/: lv_msgbox.c
    Source/ThirdParty/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    Source/ThirdParty/lvgl/src/widgets/roller/: lv_roller.c
    Source/ThirdParty/lvgl/src/widgets/scale/: lv_scale.c
    Source/ThirdParty/lvgl/src/widgets/slider/: lv_slider.c
    Source/ThirdParty/lvgl/src/widgets/span/: lv_span.c
    Source/ThirdParty/lvgl/src/widgets/spinbox/: lv_spinbox.c
    Source/ThirdParty/lvgl/src/widgets/spinner/: lv_spinner.c
    Source/ThirdParty/lvgl/src/widgets/switch/: lv_switch.c
    Source/ThirdParty/lvgl/src/widgets/table/: lv_table.c
    Source/ThirdParty/lvgl/src/widgets/tabview/: lv_tabview.c
    Source/ThirdParty/lvgl/src/widgets/textarea/: lv_textarea.c
    Source/ThirdParty/lvgl/src/widgets/tileview/: lv_tileview.c
    Source/ThirdParty/lvgl/src/widgets/win/: lv_win.c
